# Keil uVision project project.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: MM32F5277E9PV MindMotion
  pack: MindMotion.MM32F5277E_DFP.1.3.0
  cpu: IRAM(0x30000000,0x1C000) IROM(0x08000000,0x40000) CPUTYPE("Star-MC1") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: projec +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=1
  c include: ..\Device\CMSIS\Core\Include;..\Device\MM32F5270\Include;..\Device\MM32F5270\Source\KEIL_StartAsm;..\Device\MM32F5270\Source;..\Device\MM32F5270\HAL_Lib\Inc;..\Hardware\LED;..\System\delay;..\Hardware\1.8TFT;..\Hardware\DHT11;..\Hardware\ADC;..\Hardware\UART
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x30000000 size 0x1c000
  scatter file: ..\Device\MM32F5270\Source\MM32F5270.sct
  group User
    ./: main.c
  group Hardware
    ../Hardware/LED/: led.c
    ../Hardware/1.8TFT/: lcd.c lcd_init.c
    ../Hardware/DHT11/: dht11.c
    ../Hardware/ADC/: adc.c
    ../Hardware/UART/: UART.c UART.h
  group System
    ../System/delay/: delay.c
  group HAL_LIB
    ../Device/MM32F5270/HAL_Lib/Src/: hal_adc.c hal_bkp.c hal_comp.c hal_cordic.c hal_crcpoly.c hal_crs.c hal_dac.c hal_dbg.c hal_dma.c hal_enet.c hal_exti.c hal_flash.c hal_flexcan.c hal_fsmc.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_lptim.c hal_lpuart.c hal_mds.c hal_misc.c hal_pwr.c hal_qspi.c hal_rcc.c hal_rtc.c hal_spi.c hal_syscfg.c hal_tim.c hal_uart.c hal_uid.c hal_wwdg.c hal_common.h
    ../Device/MM32F5270/HAL_Lib/Inc/: hal_device_registers.h hal_dma_request.h
  group STARTUP
    ../Device/MM32F5270/Source/: system_mm32f5270.c mm32f5277e_features.h
    ../Device/MM32F5270/Source/KEIL_StartAsm/: startup_mm32f5270_keil.c
